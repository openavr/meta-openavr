require linux-common-cfg.inc
