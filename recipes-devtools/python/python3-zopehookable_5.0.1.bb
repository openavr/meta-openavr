DESCRIPTION = "Zope Hookable Module"
HOMEPAGE = "http://github.com/zopefoundation/zope.hookable"
LICENSE = "ZPL-2.1"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

PYPI_PACKAGE = "zope.hookable"

inherit pypi setuptools3

SRC_URI[md5sum] = "88354666d48df31c75d20e52afd2d0fe"
SRC_URI[sha256sum] = "29d07681a78042cdd15b268ae9decffed9ace68a53eebeb61d65ae931d158841"

RDEPENDS_${PN} = "\
"
