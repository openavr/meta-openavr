DESCRIPTION = "Parse human-readable date/time strings"
HOMEPAGE = "https://github.com/bear/parsedatetime"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=34a845f28f361454a6913882b4d3bb53"

inherit pypi setuptools3

SRC_URI[md5sum] = "fb8918fe699d79a470dcd959b77466d7"
SRC_URI[sha256sum] = "4cb368fbb18a0b7231f4d76119165451c8d2e35951455dfee97c62a87b04d455"
