DESCRIPTION = "Zope basic event publishing system"
HOMEPAGE = "https://github.com/zopefoundation/zope.event"
LICENSE = "ZPL-2.1"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

PYPI_PACKAGE = "zope.event"

inherit pypi setuptools3

SRC_URI[md5sum] = "bc38324cb29ce2d759c3cb56ea199995"
SRC_URI[sha256sum] = "5e76517f5b9b119acf37ca8819781db6c16ea433f7e2062c4afc2b6fbedb1330"

RDEPENDS_${PN} = "\
"
