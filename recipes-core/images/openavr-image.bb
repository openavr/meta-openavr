SUMMARY = "OpenAVR Reference OS Image"

IMAGE_LINGUAS = " "

LICENSE = "MIT"

include recipes-core/images/openavr-image.inc
