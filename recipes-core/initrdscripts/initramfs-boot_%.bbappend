FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# The `init-boot.sh` file will be picked up here instead of the upsteam version.
